# Altium PCB PCB2201B_A02.PcbDoc (part 6 of 7)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 114.9 x 59.9 mm, 6 copper layers (Top Layer, Signal Layer 2, Signal Layer 3, Signal Layer 4, Signal Layer 5, Bottom Layer), stack 1.555 mm thick; 371 components, 308 nets, 1384 pads, 1155 vias.

## Keep-outs
Bottom Layer:
  region: 68.25,54.063 ccw(c69.05,54.063) 69.05,53.263 ccw(c69.05,54.063) 69.85,54.063 ccw(c69.05,54.063) 69.05,54.863 ccw(c69.05,54.063)
  region: 65.71,54.063 ccw(c66.51,54.063) 66.51,53.263 ccw(c66.51,54.063) 67.31,54.063 ccw(c66.51,54.063) 66.51,54.863 ccw(c66.51,54.063)
  region: 42.85,54.063 ccw(c43.65,54.063) 43.65,53.263 ccw(c43.65,54.063) 44.45,54.063 ccw(c43.65,54.063) 43.65,54.863 ccw(c43.65,54.063)
  region: 40.31,54.063 ccw(c41.11,54.063) 41.11,53.263 ccw(c41.11,54.063) 41.91,54.063 ccw(c41.11,54.063) 41.11,54.863 ccw(c41.11,54.063)
  region: 37.77,54.063 ccw(c38.57,54.063) 38.57,53.263 ccw(c38.57,54.063) 39.37,54.063 ccw(c38.57,54.063) 38.57,54.863 ccw(c38.57,54.063)
  region: 35.23,54.063 ccw(c36.03,54.063) 36.03,53.263 ccw(c36.03,54.063) 36.83,54.063 ccw(c36.03,54.063) 36.03,54.863 ccw(c36.03,54.063)
  region: 32.69,54.063 ccw(c33.49,54.063) 33.49,53.263 ccw(c33.49,54.063) 34.29,54.063 ccw(c33.49,54.063) 33.49,54.863 ccw(c33.49,54.063)
  region: 68.25,56.603 ccw(c69.05,56.603) 69.05,55.803 ccw(c69.05,56.603) 69.85,56.603 ccw(c69.05,56.603) 69.05,57.403 ccw(c69.05,56.603)
  region: 65.71,56.603 ccw(c66.51,56.603) 66.51,55.803 ccw(c66.51,56.603) 67.31,56.603 ccw(c66.51,56.603) 66.51,57.403 ccw(c66.51,56.603)
  region: 63.17,56.603 ccw(c63.97,56.603) 63.97,55.803 ccw(c63.97,56.603) 64.77,56.603 ccw(c63.97,56.603) 63.97,57.403 ccw(c63.97,56.603)
  region: 60.63,56.603 ccw(c61.43,56.603) 61.43,55.803 ccw(c61.43,56.603) 62.23,56.603 ccw(c61.43,56.603) 61.43,57.403 ccw(c61.43,56.603)
  region: 58.09,56.603 ccw(c58.89,56.603) 58.89,55.803 ccw(c58.89,56.603) 59.69,56.603 ccw(c58.89,56.603) 58.89,57.403 ccw(c58.89,56.603)
  region: 53.01,56.603 ccw(c53.81,56.603) 53.81,55.803 ccw(c53.81,56.603) 54.61,56.603 ccw(c53.81,56.603) 53.81,57.403 ccw(c53.81,56.603)
  region: 50.47,56.603 ccw(c51.27,56.603) 51.27,55.803 ccw(c51.27,56.603) 52.07,56.603 ccw(c51.27,56.603) 51.27,57.403 ccw(c51.27,56.603)
  region: 47.93,56.603 ccw(c48.73,56.603) 48.73,55.803 ccw(c48.73,56.603) 49.53,56.603 ccw(c48.73,56.603) 48.73,57.403 ccw(c48.73,56.603)
  region: 45.39,56.603 ccw(c46.19,56.603) 46.19,55.803 ccw(c46.19,56.603) 46.99,56.603 ccw(c46.19,56.603) 46.19,57.403 ccw(c46.19,56.603)
  region: 42.85,56.603 ccw(c43.65,56.603) 43.65,55.803 ccw(c43.65,56.603) 44.45,56.603 ccw(c43.65,56.603) 43.65,57.403 ccw(c43.65,56.603)
  region: 40.31,56.603 ccw(c41.11,56.603) 41.11,55.803 ccw(c41.11,56.603) 41.91,56.603 ccw(c41.11,56.603) 41.11,57.403 ccw(c41.11,56.603)
  region: 37.77,56.603 ccw(c38.57,56.603) 38.57,55.803 ccw(c38.57,56.603) 39.37,56.603 ccw(c38.57,56.603) 38.57,57.403 ccw(c38.57,56.603)
  region: 35.23,56.603 ccw(c36.03,56.603) 36.03,55.803 ccw(c36.03,56.603) 36.83,56.603 ccw(c36.03,56.603) 36.03,57.403 ccw(c36.03,56.603)
  region: 32.69,56.603 ccw(c33.49,56.603) 33.49,55.803 ccw(c33.49,56.603) 34.29,56.603 ccw(c33.49,56.603) 33.49,57.403 ccw(c33.49,56.603)
  region: 68.25,3.263 ccw(c69.05,3.263) 69.05,2.463 ccw(c69.05,3.263) 69.85,3.263 ccw(c69.05,3.263) 69.05,4.063 ccw(c69.05,3.263)
  region: 65.71,3.263 ccw(c66.51,3.263) 66.51,2.463 ccw(c66.51,3.263) 67.31,3.263 ccw(c66.51,3.263) 66.51,4.063 ccw(c66.51,3.263)
  region: 63.17,3.263 ccw(c63.97,3.263) 63.97,2.463 ccw(c63.97,3.263) 64.77,3.263 ccw(c63.97,3.263) 63.97,4.063 ccw(c63.97,3.263)
  region: 60.63,3.263 ccw(c61.43,3.263) 61.43,2.463 ccw(c61.43,3.263) 62.23,3.263 ccw(c61.43,3.263) 61.43,4.063 ccw(c61.43,3.263)
  region: 58.09,3.263 ccw(c58.89,3.263) 58.89,2.463 ccw(c58.89,3.263) 59.69,3.263 ccw(c58.89,3.263) 58.89,4.063 ccw(c58.89,3.263)
  region: 55.55,3.263 ccw(c56.35,3.263) 56.35,2.463 ccw(c56.35,3.263) 57.15,3.263 ccw(c56.35,3.263) 56.35,4.063 ccw(c56.35,3.263)
  region: 53.01,3.263 ccw(c53.81,3.263) 53.81,2.463 ccw(c53.81,3.263) 54.61,3.263 ccw(c53.81,3.263) 53.81,4.063 ccw(c53.81,3.263)
  region: 50.47,3.263 ccw(c51.27,3.263) 51.27,2.463 ccw(c51.27,3.263) 52.07,3.263 ccw(c51.27,3.263) 51.27,4.063 ccw(c51.27,3.263)
  region: 47.93,3.263 ccw(c48.73,3.263) 48.73,2.463 ccw(c48.73,3.263) 49.53,3.263 ccw(c48.73,3.263) 48.73,4.063 ccw(c48.73,3.263)
  region: 45.39,3.263 ccw(c46.19,3.263) 46.19,2.463 ccw(c46.19,3.263) 46.99,3.263 ccw(c46.19,3.263) 46.19,4.063 ccw(c46.19,3.263)
  region: 42.85,3.263 ccw(c43.65,3.263) 43.65,2.463 ccw(c43.65,3.263) 44.45,3.263 ccw(c43.65,3.263) 43.65,4.063 ccw(c43.65,3.263)
  region: 40.31,3.263 ccw(c41.11,3.263) 41.11,2.463 ccw(c41.11,3.263) 41.91,3.263 ccw(c41.11,3.263) 41.11,4.063 ccw(c41.11,3.263)
  region: 37.77,3.263 ccw(c38.57,3.263) 38.57,2.463 ccw(c38.57,3.263) 39.37,3.263 ccw(c38.57,3.263) 38.57,4.063 ccw(c38.57,3.263)
  region: 35.23,3.263 ccw(c36.03,3.263) 36.03,2.463 ccw(c36.03,3.263) 36.83,3.263 ccw(c36.03,3.263) 36.03,4.063 ccw(c36.03,3.263)
  region: 32.69,3.263 ccw(c33.49,3.263) 33.49,2.463 ccw(c33.49,3.263) 34.29,3.263 ccw(c33.49,3.263) 33.49,4.063 ccw(c33.49,3.263)
  region: 30.15,5.803 ccw(c30.95,5.803) 30.95,5.003 ccw(c30.95,5.803) 31.75,5.803 ccw(c30.95,5.803) 30.95,6.603 ccw(c30.95,5.803)
  region: 68.25,5.803 ccw(c69.05,5.803) 69.05,5.003 ccw(c69.05,5.803) 69.85,5.803 ccw(c69.05,5.803) 69.05,6.603 ccw(c69.05,5.803)
  region: 65.71,5.803 ccw(c66.51,5.803) 66.51,5.003 ccw(c66.51,5.803) 67.31,5.803 ccw(c66.51,5.803) 66.51,6.603 ccw(c66.51,5.803)
  region: 63.17,5.803 ccw(c63.97,5.803) 63.97,5.003 ccw(c63.97,5.803) 64.77,5.803 ccw(c63.97,5.803) 63.97,6.603 ccw(c63.97,5.803)
  region: 60.63,5.803 ccw(c61.43,5.803) 61.43,5.003 ccw(c61.43,5.803) 62.23,5.803 ccw(c61.43,5.803) 61.43,6.603 ccw(c61.43,5.803)
  region: 58.09,5.803 ccw(c58.89,5.803) 58.89,5.003 ccw(c58.89,5.803) 59.69,5.803 ccw(c58.89,5.803) 58.89,6.603 ccw(c58.89,5.803)
  region: 55.55,5.803 ccw(c56.35,5.803) 56.35,5.003 ccw(c56.35,5.803) 57.15,5.803 ccw(c56.35,5.803) 56.35,6.603 ccw(c56.35,5.803)
  region: 53.01,5.803 ccw(c53.81,5.803) 53.81,5.003 ccw(c53.81,5.803) 54.61,5.803 ccw(c53.81,5.803) 53.81,6.603 ccw(c53.81,5.803)
  region: 50.47,5.803 ccw(c51.27,5.803) 51.27,5.003 ccw(c51.27,5.803) 52.07,5.803 ccw(c51.27,5.803) 51.27,6.603 ccw(c51.27,5.803)
  region: 47.93,5.803 ccw(c48.73,5.803) 48.73,5.003 ccw(c48.73,5.803) 49.53,5.803 ccw(c48.73,5.803) 48.73,6.603 ccw(c48.73,5.803)
  region: 45.39,5.803 ccw(c46.19,5.803) 46.19,5.003 ccw(c46.19,5.803) 46.99,5.803 ccw(c46.19,5.803) 46.19,6.603 ccw(c46.19,5.803)
  region: 42.85,5.803 ccw(c43.65,5.803) 43.65,5.003 ccw(c43.65,5.803) 44.45,5.803 ccw(c43.65,5.803) 43.65,6.603 ccw(c43.65,5.803)
  region: 40.31,5.803 ccw(c41.11,5.803) 41.11,5.003 ccw(c41.11,5.803) 41.91,5.803 ccw(c41.11,5.803) 41.11,6.603 ccw(c41.11,5.803)
  region: 37.77,5.803 ccw(c38.57,5.803) 38.57,5.003 ccw(c38.57,5.803) 39.37,5.803 ccw(c38.57,5.803) 38.57,6.603 ccw(c38.57,5.803)
  region: 35.23,5.803 ccw(c36.03,5.803) 36.03,5.003 ccw(c36.03,5.803) 36.83,5.803 ccw(c36.03,5.803) 36.03,6.603 ccw(c36.03,5.803)
  region: 32.69,5.803 ccw(c33.49,5.803) 33.49,5.003 ccw(c33.49,5.803) 34.29,5.803 ccw(c33.49,5.803) 33.49,6.603 ccw(c33.49,5.803)
  region: 103.499,19.001 cw(c103.499,18.501) 103.999,18.501 cw(c103.499,18.501) 103.499,18.001 cw(c103.499,18.501) 102.999,18.501 cw(c103.499,18.501)
  region: 108.249,40.201 cw(c108.249,39.7) 108.749,39.701 cw(c108.249,39.701) 108.249,39.201 cw(c108.249,39.701) 107.749,39.701 cw(c108.249,39.7)
  region: 108.249,43.749 cw(c108.249,43.249) 108.749,43.249 cw(c108.249,43.249) 108.249,42.749 cw(c108.249,43.249) 107.749,43.249 cw(c108.249,43.249)
  region: 106.999,54.201 cw(c106.999,53.701) 107.499,53.701 cw(c106.999,53.701) 106.999,53.201 cw(c106.999,53.701) 106.499,53.701 cw(c106.999,53.701)
  region: 105.399,52.499 cw(c105.399,51.999) 105.899,51.999 cw(c105.399,51.999) 105.399,51.499 cw(c105.399,51.999) 104.899,51.999 cw(c105.399,51.999)
  region: 104.449,54.201 cw(c104.449,53.701) 104.949,53.701 cw(c104.449,53.701) 104.449,53.201 cw(c104.449,53.701) 103.949,53.701 cw(c104.449,53.701)
  region: 103.398,52.499 cw(c103.398,51.999) 103.898,51.999 cw(c103.398,51.999) 103.398,51.499 cw(c103.398,51.999) 102.898,51.999 cw(c103.398,51.999)
  region: 102.648,48.849 cw(c102.648,48.349) 103.148,48.349 cw(c102.648,48.349) 102.648,47.849 cw(c102.648,48.349) 102.148,48.349 cw(c102.648,48.349)
  region: 97.398,47.701 cw(c97.398,47.201) 97.898,47.201 cw(c97.398,47.201) 97.398,46.701 cw(c97.398,47.201) 96.898,47.201 cw(c97.398,47.201)
  region: 92.524,52.433 cw(c92.524,51.933) 93.024,51.933 cw(c92.524,51.933) 92.524,51.433 cw(c92.524,51.933) 92.024,51.933 cw(c92.524,51.933)
  region: 93.54,54.211 cw(c93.54,53.711) 94.04,53.711 cw(c93.54,53.711) 93.54,53.211 cw(c93.54,53.711) 93.04,53.711 cw(c93.54,53.711)
  region: 90.492,52.433 cw(c90.492,51.933) 90.992,51.933 cw(c90.492,51.933) 90.492,51.433 cw(c90.492,51.933) 89.992,51.933 cw(c90.492,51.933)
  region: 88.46,52.433 cw(c88.46,51.933) 88.96,51.933 cw(c88.46,51.933) 88.46,51.433 cw(c88.46,51.933) 87.96,51.933 cw(c88.46,51.933)
  region: 89.476,54.211 cw(c89.476,53.711) 89.976,53.711 cw(c89.476,53.711) 89.476,53.211 cw(c89.476,53.711) 88.976,53.711 cw(c89.476,53.711)
  region: 87.465,54.207 cw(c87.466,53.707) 87.966,53.707 cw(c87.465,53.708) 87.465,53.207 cw(c87.465,53.707) 86.966,53.707 cw(c87.466,53.707)
  region: 84.348,54.8 cw(c84.348,54.3) 84.848,54.301 cw(c84.348,54.301) 84.348,53.8 cw(c84.348,54.3) 83.848,54.3 cw(c84.348,54.3)
  region: 85.399,52.199 cw(c85.399,51.699) 85.899,51.7 cw(c85.399,51.7) 85.399,51.2 cw(c85.399,51.699) 84.899,51.699 cw(c85.399,51.699)
  region: 93.448,42.799 cw(c93.448,42.299) 93.949,42.299 cw(c93.448,42.299) 93.448,41.799 cw(c93.448,42.299) 92.948,42.299 cw(c93.449,42.299)
  region: 86.148,40.051 cw(c86.149,39.551) 86.649,39.551 cw(c86.148,39.551) 86.148,39.051 cw(c86.148,39.551) 85.649,39.551 cw(c86.149,39.551)
  region: 81.648,53.95 cw(c81.648,53.45) 82.148,53.45 cw(c81.648,53.45) 81.648,52.95 cw(c81.648,53.45) 81.148,53.45 cw(c81.648,53.449)
  region: 77.899,53.2 cw(c77.899,52.7) 78.399,52.7 cw(c77.898,52.7) 77.899,52.2 cw(c77.899,52.7) 77.399,52.7 cw(c77.899,52.7)
  region: 80.2,51.45 cw(c80.2,50.95) 80.7,50.95 cw(c80.2,50.95) 80.2,50.45 cw(c80.2,50.95) 79.7,50.95 cw(c80.2,50.95)
  region: 77.398,48.499 cw(c77.398,47.999) 77.898,47.999 cw(c77.398,47.999) 77.398,47.499 cw(c77.398,47.999) 76.898,47.999 cw(c77.398,47.999)
  region: 75.399,48.499 cw(c75.399,47.999) 75.899,47.999 cw(c75.399,47.999) 75.399,47.499 cw(c75.399,47.999) 74.899,47.999 cw(c75.399,47.999)
  region: 73.398,48.499 cw(c73.398,47.999) 73.898,47.999 cw(c73.398,47.999) 73.398,47.499 cw(c73.398,47.999) 72.898,47.999 cw(c73.398,47.999)
  region: 77.398,46.299 cw(c77.398,45.799) 77.898,45.799 cw(c77.398,45.799) 77.398,45.299 cw(c77.398,45.799) 76.898,45.799 cw(c77.398,45.799)
  region: 75.399,46.299 cw(c75.399,45.799) 75.899,45.799 cw(c75.399,45.799) 75.399,45.299 cw(c75.399,45.799) 74.899,45.799 cw(c75.399,45.799)
  region: 73.398,46.299 cw(c73.398,45.799) 73.898,45.799 cw(c73.398,45.799) 73.398,45.299 cw(c73.398,45.799) 72.898,45.799 cw(c73.398,45.799)
  region: 71.399,46.299 cw(c71.399,45.799) 71.899,45.799 cw(c71.399,45.799) 71.399,45.299 cw(c71.399,45.799) 70.899,45.799 cw(c71.399,45.799)
  region: 73.398,43.599 cw(c73.398,43.099) 73.898,43.099 cw(c73.398,43.099) 73.398,42.599 cw(c73.398,43.099) 72.898,43.099 cw(c73.398,43.099)
  region: 71.549,41.45 cw(c71.549,40.95) 72.049,40.95 cw(c71.548,40.95) 71.549,40.45 cw(c71.549,40.95) 71.049,40.95 cw(c71.549,40.95)
  region: 66.649,44.6 cw(c66.649,44.1) 67.149,44.1 cw(c66.649,44.1) 66.649,43.6 cw(c66.649,44.1) 66.149,44.1 cw(c66.649,44.1)
  region: 94.198,12.349 cw(c94.198,11.849) 94.698,11.849 cw(c94.198,11.85) 94.198,11.349 cw(c94.198,11.849) 93.698,11.849 cw(c94.198,11.849)
  region: 96.799,11.801 cw(c96.799,11.301) 97.299,11.301 cw(c96.799,11.301) 96.799,10.801 cw(c96.799,11.301) 96.299,11.301 cw(c96.799,11.301)
  region: 93.248,9.949 cw(c93.248,9.449) 93.748,9.449 cw(c93.248,9.449) 93.248,8.949 cw(c93.248,9.449) 92.748,9.449 cw(c93.248,9.449)
  region: 96.499,9.149 cw(c96.499,8.649) 96.999,8.649 cw(c96.499,8.649) 96.499,8.149 cw(c96.499,8.649) 95.999,8.649 cw(c96.499,8.649)
  region: 95.699,6.551 cw(c95.699,6.051) 96.199,6.051 cw(c95.699,6.051) 95.699,5.551 cw(c95.699,6.051) 95.199,6.051 cw(c95.699,6.05)
  region: 93.248,7.399 cw(c93.248,6.899) 93.748,6.899 cw(c93.248,6.899) 93.248,6.399 cw(c93.248,6.899) 92.748,6.899 cw(c93.248,6.899)
  region: 81.498,10.95 cw(c81.498,10.45) 81.998,10.45 cw(c81.498,10.45) 81.498,9.95 cw(c81.498,10.45) 80.998,10.45 cw(c81.498,10.45)
  region: 77.248,10.95 cw(c77.248,10.45) 77.748,10.45 cw(c77.248,10.45) 77.248,9.95 cw(c77.248,10.45) 76.748,10.45 cw(c77.248,10.45)
  region: 72.948,10.95 cw(c72.948,10.45) 73.448,10.45 cw(c72.948,10.45) 72.948,9.95 cw(c72.948,10.45) 72.448,10.45 cw(c72.948,10.45)
  region: 74.099,6.749 cw(c74.099,6.249) 74.599,6.249 cw(c74.099,6.249) 74.099,5.749 cw(c74.099,6.249) 73.599,6.249 cw(c74.099,6.249)
  region: 54.673,41.625 cw(c54.673,41.125) 55.173,41.126 cw(c54.673,41.126) 54.673,40.626 cw(c54.673,41.125) 54.173,41.125 cw(c54.673,41.125)
  region: 52.747,39.751 cw(c52.748,39.251) 53.248,39.251 cw(c52.747,39.251) 52.747,38.751 cw(c52.747,39.251) 52.248,39.251 cw(c52.748,39.251)
  region: 50.749,34.724 cw(c50.749,34.224) 51.249,34.224 cw(c50.748,34.224) 50.749,33.724 cw(c50.749,34.224) 50.249,34.224 cw(c50.749,34.224)
  region: 53.898,33.099 cw(c53.898,32.599) 54.398,32.599 cw(c53.898,32.599) 53.898,32.099 cw(c53.898,32.599) 53.398,32.599 cw(c53.898,32.599)
  region: 50.749,31.001 cw(c50.749,30.501) 51.249,30.501 cw(c50.748,30.501) 50.749,30.001 cw(c50.749,30.501) 50.249,30.501 cw(c50.749,30.501)
  region: 53.949,30.551 cw(c53.949,30.051) 54.449,30.051 cw(c53.949,30.051) 53.949,29.551 cw(c53.949,30.051) 53.449,30.051 cw(c53.949,30.051)
  region: 54.498,28.1 cw(c54.498,27.6) 54.998,27.6 cw(c54.497,27.6) 54.498,27.1 cw(c54.498,27.6) 53.998,27.6 cw(c54.498,27.6)
  region: 51.798,28.1 cw(c51.798,27.6) 52.298,27.6 cw(c51.797,27.6) 51.798,27.1 cw(c51.798,27.6) 51.298,27.6 cw(c51.798,27.6)
  region: 53.149,25.951 cw(c53.149,25.451) 53.649,25.451 cw(c53.149,25.451) 53.149,24.951 cw(c53.149,25.451) 52.649,25.451 cw(c53.149,25.451)
  region: 47.998,30.15 cw(c47.998,29.65) 48.498,29.65 cw(c47.998,29.65) 47.998,29.15 cw(c47.998,29.65) 47.498,29.65 cw(c47.998,29.65)
  region: 45.448,29.35 cw(c45.448,28.85) 45.948,28.85 cw(c45.447,28.85) 45.448,28.35 cw(c45.448,28.85) 44.948,28.85 cw(c45.448,28.85)
  region: 46.999,25.75 cw(c47,25.25) 47.5,25.251 cw(c46.999,25.251) 46.999,24.751 cw(c46.999,25.25) 46.499,25.25 cw(c47,25.25)
  region: 43.248,28.001 cw(c43.248,27.501) 43.748,27.501 cw(c43.248,27.501) 43.248,27.001 cw(c43.248,27.501) 42.748,27.501 cw(c43.248,27.501)
  region: 44.498,25.75 cw(c44.498,25.25) 44.998,25.251 cw(c44.497,25.251) 44.498,24.751 cw(c44.498,25.25) 43.998,25.25 cw(c44.498,25.25)
  region: 41.998,25.75 cw(c41.998,25.25) 42.498,25.251 cw(c41.998,25.251) 41.998,24.751 cw(c41.998,25.25) 41.498,25.25 cw(c41.998,25.25)
  region: 61.3,16.599 cw(c61.3,16.099) 61.8,16.099 cw(c61.3,16.099) 61.3,15.599 cw(c61.3,16.099) 60.8,16.099 cw(c61.3,16.099)
  region: 51.95,16.599 cw(c51.95,16.099) 52.45,16.099 cw(c51.95,16.099) 51.95,15.599 cw(c51.95,16.099) 51.45,16.099 cw(c51.95,16.099)
  region: 34.523,21.026 cw(c34.523,20.526) 35.023,20.526 cw(c34.523,20.526) 34.523,20.026 cw(c34.523,20.526) 34.023,20.526 cw(c34.523,20.526)
  region: 24.449,17.6 cw(c24.449,17.1) 24.949,17.1 cw(c24.449,17.1) 24.449,16.6 cw(c24.449,17.1) 23.949,17.1 cw(c24.449,17.099)
  region: 15.648,26.449 cw(c15.648,25.949) 16.148,25.949 cw(c15.648,25.949) 15.648,25.449 cw(c15.648,25.949) 15.148,25.949 cw(c15.648,25.949)
  region: 12.049,26.449 cw(c12.049,25.949) 12.549,25.949 cw(c12.049,25.949) 12.049,25.449 cw(c12.049,25.949) 11.549,25.949 cw(c12.049,25.949)
  region: 12.024,29.774 cw(c12.024,29.274) 12.524,29.274 cw(c12.024,29.274) 12.024,28.774 cw(c12.024,29.274) 11.524,29.274 cw(c12.024,29.274)
  region: 9.474,29.799 cw(c9.474,29.299) 9.974,29.299 cw(c9.473,29.299) 9.474,28.799 cw(c9.474,29.299) 8.974,29.299 cw(c9.474,29.299)
  region: 14.348,32.799 cw(c14.348,32.299) 14.848,32.299 cw(c14.348,32.299) 14.348,31.799 cw(c14.348,32.299) 13.848,32.299 cw(c14.348,32.299)
  region: 10.398,32.25 cw(c10.398,31.75) 10.898,31.75 cw(c10.398,31.751) 10.398,31.25 cw(c10.398,31.75) 9.898,31.75 cw(c10.398,31.75)
  region: 10.398,34.9 cw(c10.398,34.4) 10.898,34.4 cw(c10.398,34.4) 10.398,33.9 cw(c10.398,34.4) 9.898,34.4 cw(c10.398,34.399)
  region: 18.445,49.045 cw(c18.445,48.545) 18.945,48.545 cw(c18.445,48.545) 18.445,48.045 cw(c18.445,48.545) 17.945,48.545 cw(c18.445,48.545)
  region: 15.905,50.315 cw(c15.905,49.815) 16.405,49.815 cw(c15.905,49.815) 15.905,49.315 cw(c15.905,49.815) 15.405,49.815 cw(c15.905,49.815)
  region: 18.445,51.585 cw(c18.445,51.085) 18.945,51.085 cw(c18.445,51.085) 18.445,50.585 cw(c18.445,51.085) 17.945,51.085 cw(c18.445,51.085)
  region: 15.905,52.855 cw(c15.905,52.355) 16.405,52.355 cw(c15.905,52.355) 15.905,51.855 cw(c15.905,52.355) 15.405,52.355 cw(c15.905,52.355)
  region: 18.445,54.125 cw(c18.445,53.625) 18.945,53.625 cw(c18.445,53.625) 18.445,53.125 cw(c18.445,53.625) 17.945,53.625 cw(c18.445,53.625)
  region: 15.905,55.395 cw(c15.905,54.895) 16.405,54.895 cw(c15.905,54.895) 15.905,54.395 cw(c15.905,54.895) 15.405,54.895 cw(c15.905,54.895)
  region: 12.699,54.351 cw(c12.699,53.851) 13.199,53.851 cw(c12.699,53.851) 12.699,53.351 cw(c12.699,53.851) 12.199,53.851 cw(c12.699,53.851)
  region: 10.149,54.351 cw(c10.149,53.851) 10.649,53.851 cw(c10.149,53.851) 10.149,53.351 cw(c10.149,53.851) 9.649,53.851 cw(c10.149,53.851)
  region: 10.149,51.801 cw(c10.149,51.301) 10.649,51.301 cw(c10.149,51.301) 10.149,50.801 cw(c10.149,51.301) 9.649,51.301 cw(c10.149,51.301)
  region: 7.548,50.3 cw(c7.548,49.8) 8.048,49.8 cw(c7.548,49.8) 7.548,49.3 cw(c7.548,49.8) 7.048,49.8 cw(c7.548,49.799)
  region: 24.599,41.9 cw(c24.599,41.4) 25.099,41.4 cw(c24.599,41.4) 24.599,40.9 cw(c24.599,41.4) 24.099,41.4 cw(c24.599,41.4)
  region: 36.248,37.549 cw(c36.248,37.049) 36.748,37.049 cw(c36.248,37.049) 36.248,36.549 cw(c36.248,37.049) 35.748,37.049 cw(c36.248,37.049)
  region: 38.974,37.544 cw(c38.974,37.044) 39.474,37.044 cw(c38.974,37.045) 38.974,36.544 cw(c38.974,37.044) 38.474,37.044 cw(c38.974,37.044)
  region: 41.599,38.4 cw(c41.599,37.9) 42.1,37.9 cw(c41.599,37.9) 41.599,37.4 cw(c41.599,37.9) 41.099,37.9 cw(c41.6,37.9)
  region: 44.048,39.05 cw(c44.048,38.55) 44.548,38.55 cw(c44.048,38.55) 44.048,38.05 cw(c44.048,38.55) 43.548,38.55 cw(c44.048,38.55)
  region: 42.648,43.924 cw(c42.648,43.424) 43.149,43.424 cw(c42.648,43.424) 42.648,42.924 cw(c42.648,43.424) 42.148,43.424 cw(c42.649,43.424)
  region: 43.949,46.101 cw(c43.949,45.601) 44.449,45.601 cw(c43.949,45.601) 43.949,45.101 cw(c43.949,45.601) 43.449,45.601 cw(c43.949,45.601)
  region: 18.445,46.505 cw(c18.445,46.005) 18.945,46.005 cw(c18.445,46.005) 18.445,45.505 cw(c18.445,46.005) 17.945,46.005 cw(c18.445,46.005)

## Other copper
Top Layer:
  region net GND: 6.147,47.052 6.147,48.181 6.03,48.298 5.208,48.298 5.208,47.629 5.691,47.146
  region net GND: 5.175,57.546 5.174,57.545 5.174,56.648 5.671,56.648 6.2,57.177 6.2,57.962
  region net GND: 80.676,3.528 80.676,5.321 80.9,5.545 80.854,5.591 80.854,6.305 81.836,6.305 82.225,5.916 82.225,3.962 82.216,3.962 81.803,3.549
  region net GND: 77.325,5.522 77.319,5.516 77.319,3.531 76.282,3.531 75.46,4.354 75.463,4.356 75.463,5.501
  pour cut-out: 81.233,37.391 81.076,37.234 81.076,28.507 89.923,28.507 89.951,28.534 89.886,28.599 89.886,37.187 81.066,37.187 81.057,37.197
  pour cut-out: 69.679,11.838 70.373,11.144 70.756,11.144 70.756,11.123 70.425,10.792 70.228,10.988 69.969,10.988 69.969,11.361 69.617,11.713 69.648,11.744 69.648,11.796
  pour cut-out: 76.261,6.394 76.304,6.351 76.304,5.96 76.251,5.96 76.248,5.957 76.241,5.964 76.241,6.423
  pour cut-out: 75.619,7.242 75.636,7.225 75.636,6.405 76.288,6.405 76.266,6.427 76.266,7.264 75.636,7.264 75.597,7.225
  pour cut-out: 68.571,9.813 68.584,9.8 68.584,8.993 69.2,8.993 69.221,8.972 69.229,8.98 69.229,9.83 68.609,9.83 68.584,9.804
  pour cut-out: 73.284,5.622 73.284,5.384 73.068,5.168 73.024,5.212 73.024,5.379 73.266,5.622
  pour cut-out: 11.355,52.959 11.425,53.028 11.425,53.825 11.912,53.825 11.886,53.799 11.886,52.933 11.33,52.933 11.324,52.94
  pour cut-out: 9.833,55.073 9.903,55.004 10.699,55.004 10.699,54.517 10.674,54.542 9.808,54.542 9.808,55.098 9.814,55.105
  pour cut-out: 6.312,55.508 6.382,55.438 7.179,55.438 7.179,54.951 7.153,54.977 6.287,54.977 6.287,55.533 6.293,55.539
  pour cut-out: 6.287,50.001 6.356,49.932 7.153,49.932 7.153,49.445 7.128,49.47 6.262,49.47 6.262,50.026 6.268,50.033
  pour cut-out: 56.18,32.11 56.68,32.11 56.824,32.254 56.801,32.277 56.801,32.294 56.392,32.294 56.203,32.104
  pour cut-out: 55.501,32.11 55.282,31.891 55.282,31.6 55.644,31.963 55.512,32.095 55.512,32.101
  pour cut-out: 52.316,31.858 52.585,31.858 52.774,32.047 52.629,32.192 52.581,32.192 52.581,32.185 52.278,31.882
  pour cut-out: 35.309,34.468 35.1,34.259 35.1,33.98 35.197,33.98 35.306,34.089 35.306,34.456
  pour cut-out: 35.737,31.169 35.739,31.172 36.183,31.172 36.183,31.063 36.179,31.059 36.177,31.061 35.676,31.061 35.676,31.174 35.697,31.194
  pour cut-out: 35.439,29.049 35.243,28.854 35.243,28.649 35.21,28.649 35.094,28.765 35.29,28.96 35.29,29.121 35.363,29.121 35.419,29.065
  pour cut-out: 30.305,25.833 30.317,25.821 30.817,25.821 30.817,25.888 30.825,25.896 30.817,25.905 30.3,25.905 30.3,25.79 30.297,25.787
  pour cut-out: 16.483,43.997 16.981,43.997 16.924,43.94 16.528,43.94 16.528,43.985 16.491,44.022
  pour cut-out: 105.978,36.933 105.998,36.913 107.391,36.913 107.391,37.061 107.404,37.074 107.377,37.101 105.945,37.101 105.945,36.899
  pour cut-out: 106.316,43.089 106.336,43.069 106.953,43.069 106.953,43.373 106.963,43.383 106.326,43.383 106.326,43.059 106.306,43.04
  pour cut-out: 111.21,40.117 110.524,39.43 110.681,39.43 111.22,39.97 111.22,40.078
  region net N17454530: 3.458,7.725 3.458,5.542 4.5,4.5 10.538,4.5 10.538,7.725
  region net N17454530: 10.542,26.275 10.542,29.5 3.462,29.5 3.462,26.275
  pour cut-out: 26.858,34.179 26.858,33.612 27.16,33.612 27.166,33.619 27.166,34.179 26.858,34.179
  pour cut-out: 50.821,36.41 50.751,36.34 50.751,35.994 50.712,35.994 50.463,36.244 50.616,36.397 50.616,36.506
  pour cut-out: 81.468,55.288 85.634,55.288 85.95,54.972 85.731,54.753 85.731,52.811 81.64,52.811 81.537,52.914 81.537,55.186
  pour cut-out: 75.118,55.288 79.065,55.288 79.313,55.041 79.313,52.914 75.187,52.914 75.118,52.983
  pour cut-out: 29.804,35.277 29.793,35.266 29.793,33.608 30.944,33.608 31.012,33.676 30.813,33.875 30.813,34.488 30.593,34.488
  pour cut-out: 51.525,25.725 51.591,25.659 51.591,25.255 52.361,25.255 52.4,25.216 52.4,25.719 51.622,25.719 51.615,25.725
  pour cut-out: 59.973,28.916 59.973,28.935 60.192,29.154 60.434,28.912 61.112,28.912 61.112,28.758 60.833,28.478 60.169,28.478 60.169,28.72
  pour cut-out: 62.239,30.221 62.72,30.221 62.855,30.086 62.855,29.772 63.029,29.772 63.109,29.692 63.109,30.47 62.584,30.47 62.453,30.6 62.225,30.372
  pour cut-out: 65.012,37.074 64.964,37.026 64.964,35.995 63.621,35.995 63.337,36.279 63.337,36.658 63.752,37.074
  pour cut-out: 60.911,36.279 60.911,36.143 60.925,36.128 60.679,35.883 60.561,35.883 60.316,36.128 60.316,36.393 60.725,36.393 60.825,36.293
  pour cut-out: 59.823,36.857 59.866,36.9 60.295,36.9 60.295,37.609 60.205,37.698 59.636,37.698 59.636,37.025 59.65,37.011
  pour cut-out: 39.244,27.597 38.965,27.318 38.965,26.193 38.959,26.186 39.108,26.037 39.576,26.037 39.576,27.545 39.502,27.619 39.366,27.619 39.355,27.609 39.355,27.517
  pour cut-out: 45.076,26.246 45.096,26.227 45.096,25.832 46.031,25.832 46.128,25.929 46.113,25.943 46.113,26.111 45.673,26.111 45.567,26.217
  pour cut-out: 73.262,7.622 73.262,7.082 73.326,7.018 73.701,7.018 73.701,7.618 73.688,7.631 73.362,7.631 73.317,7.676
  pour cut-out: 100.323,55.3 102.027,55.3 102.027,53.186 101.941,53.1 101.933,53.109 100.107,53.109 100.107,55.258 100.219,55.37 100.393,55.196
  pour cut-out: 101.593,58.983 103.287,58.983 103.35,58.92 103.283,58.854 103.283,56.591 101.634,56.591 101.536,56.689 101.552,56.704 101.552,58.959
  pour cut-out: 93.137,58.983 93.176,58.944 93.176,56.581 92.74,56.581 92.643,56.678 92.643,58.929
  pour cut-out: 49.45,38.475 49.45,36.55 50.85,36.55 50.85,38.475
  pour cut-out: 56.675,45.4 56.675,43.475 58.075,43.475 58.075,45.4
  region net 3V3: 102.098,40.1 106.398,40.1 106.398,43.1 102.098,43.1
  pour cut-out: 78.65,30.275 78.65,28.075 80.05,28.075 80.05,30.275
  region net BC_I2C_EXP_SDA: 111.206,40.1 106.906,40.1 106.906,43.1 111.206,43.1
  region net GND: 111.206,19.9 106.906,19.9 106.906,16.9 111.206,16.9
  region net VMCU: 102.098,19.9 106.398,19.9 106.398,16.9 102.098,16.9
  pour cut-out: 30.7,9.4 30.7,18.4 60.7,18.4 60.7,9.4
  pour cut-out: 108.35,7.275 108.35,12.825 113.75,12.825 113.75,7.275
Signal Layer 2:
  pour cut-out: 30.7,9.4 30.7,18.4 60.7,18.4 60.7,9.4
  pour cut-out: 108.35,7.275 108.35,12.825 113.75,12.825 113.75,7.275
Signal Layer 3:
  pour cut-out: 88.209,23.328 88.17,23.289 88.17,22.77 88.024,22.77 87.914,22.879 87.993,22.958 87.993,23.274
  pour cut-out: 80.523,22.158 80.496,22.131 80.496,21.663 80.856,21.663 80.838,21.681 80.838,22.248 80.622,22.248 80.586,22.212
  pour cut-out: 81.765,19.917 81.783,19.899 81.783,19.179 81.999,19.179 82.026,19.206 81.864,19.368 81.864,20.025 81.846,20.025 81.819,19.998
  pour cut-out: 45.774,21.096 45.756,21.078 45.756,20.232 46.116,20.232 45.963,20.385 45.963,21.258 45.702,21.258 45.729,21.231 45.747,21.231 45.747,21.123
  pour cut-out: 33.374,49.741 38.622,49.741 39.219,50.338 33.637,50.338 33.5,50.2
  pour cut-out: 39.517,52.863 39.517,51.662 39.582,51.597 39.591,51.606 39.708,51.606 39.708,52.924 39.643,52.989
  pour cut-out: 71.172,36.234 71.172,33.537 71.212,33.496 71.177,33.461 71.074,33.461 71.074,36.179 71.073,36.18
  pour cut-out: 72.072,39.303 72.072,36.606 72.112,36.565 72.077,36.53 71.974,36.53 71.974,39.248 71.973,39.249
  pour cut-out: 80.883,37.467 80.883,34.77 80.923,34.729 80.784,33.074 80.785,34.694 80.785,37.412 80.784,37.413
  pour cut-out: 89.375,41.269 89.375,38.572 89.416,38.532 89.38,38.496 89.278,38.496 89.278,41.214 89.276,41.215
  pour cut-out: 89.496,41.328 75.888,33.534 76.347,39.69
  pour cut-out: 62.856,24.372 62.874,24.354 62.874,22.923 63.126,22.923 63.063,22.986 63.063,24.363
  pour cut-out: 75.429,25.452 75.429,22.755 75.469,22.714 75.434,22.679 75.331,22.679 75.331,25.397 75.33,25.398
  pour cut-out: 62.73,27.108 62.73,26.674 62.569,26.512 62.305,26.512 62.305,27.074 62.271,27.108
  pour cut-out: 54,26.577 53.868,26.445 53.868,26.155 54.152,26.155 54.153,26.154 54.153,26.541
  pour cut-out: 71.487,16.589 71.487,15.714 71.226,15.453 70.893,15.453 70.893,16.263 70.83,16.326
  pour cut-out: 70.767,17.676 70.568,17.477 70.568,17.278 70.351,17.278 70.29,17.217 70.29,17.685
  pour cut-out: 40.689,2.655 40.599,2.745 39.339,2.745 39.339,2.385 39.408,2.454 40.644,2.454
  pour cut-out: 88.209,28.767 88.092,28.649 87.803,28.649 89.659,26.793 90.486,26.793 90.486,27.342 90.495,27.351 90.477,27.369 89.397,27.369 89.397,27.579
  pour cut-out: 54.019,38.734 54.065,38.688 54.065,38.154 55.652,38.154 55.896,38.398 55.652,38.643 55.652,39.778 55.478,39.778 55.188,39.488 54.873,39.488
  pour cut-out: 59.685,42.722 59.685,42.332 59.586,42.233 60.041,41.779 60.041,41.572 60.228,41.572 60.515,41.858 60.515,42.352 60.386,42.352 59.957,42.782
  pour cut-out: 60.561,40.77 60.561,40.329 60.278,40.045 63.355,40.045 63.355,40.268 63.434,40.347 63.093,40.687 62.821,40.687
  pour cut-out: 71.789,43.233 71.789,43.043 71.871,42.961 86.616,42.961 86.616,43.299 86.609,43.306 71.817,43.306
  pour cut-out: 72.205,52.233 72.158,52.186 72.158,51.867 73.343,50.682 73.556,50.682 73.556,51.118 72.429,52.245 72.328,52.245
  pour cut-out: 30.7,9.4 30.7,18.4 60.7,18.4 60.7,9.4
  pour cut-out: 108.35,7.275 108.35,12.825 113.75,12.825 113.75,7.275
Signal Layer 4:
  pour cut-out: 98.14,51.76 99.183,51.76 99.221,51.799 99.132,51.888 99.132,52.132 98.293,52.132 98.127,51.965 98.127,51.767
  pour cut-out: 100.767,57.283 100.795,57.255 100.795,56.58 101.102,56.58 101.262,56.74 101.262,57.22 100.879,57.22 100.795,57.304
  pour cut-out: 89.605,7.714 89.692,7.627 91.071,7.627 91.071,7.438 91.158,7.351 90.926,7.118 90.011,7.118 89.474,7.656
  pour cut-out: 91.855,15.364 92.378,14.841 92.465,14.841 92.131,14.508 91.913,14.725 91.812,14.725 91.812,15.277 91.797,15.291
  pour cut-out: 108.477,52.65 108.868,52.713 108.896,52.686 109.125,53.388 108.527,52.938
  pour cut-out: 106.858,53.198 107.249,53.261 107.276,53.234 107.506,53.936 106.907,53.486
  pour cut-out: 92.475,26.586 92.866,26.649 92.894,26.622 93.123,27.324 92.525,26.874
  pour cut-out: 94.086,26.316 94.477,26.379 94.505,26.352 94.734,27.054 94.136,26.604
  pour cut-out: 87.219,22.248 87.611,22.311 87.638,22.284 87.867,22.986 87.269,22.536
  pour cut-out: 67.284,15.552 67.676,15.615 67.703,15.588 67.932,16.29 67.334,15.84
  pour cut-out: 49.492,3.503 49.771,3.503 50.369,2.905 50.369,3.728 49.429,3.728
  pour cut-out: 52.738,3.262 53.017,3.262 53.044,3.235 53.044,3.487 52.675,3.487
  pour cut-out: 63.79,27.322 64.203,27.537 64.23,27.51 64.23,27.762 63.861,27.762
  pour cut-out: 49.888,7.278 50.167,7.278 50.194,7.251 50.194,7.551 49.812,7.551
  pour cut-out: 47.88,7.865 48.159,7.865 48.186,7.838 48.186,8.127 47.807,8.127
  pour cut-out: 65.992,16.875 66.271,16.875 66.299,16.848 66.299,17.1 65.929,17.1
  pour cut-out: 64.593,19.152 64.985,19.215 65.012,19.188 65.241,19.89 64.643,19.44
  pour cut-out: 78.486,23.418 78.765,23.418 78.792,23.391 78.792,23.643 78.423,23.643
  pour cut-out: 76.388,23.319 76.666,23.319 76.694,23.292 76.694,23.544 76.325,23.544
  pour cut-out: 74.245,22.423 74.688,22.423 74.688,22.675 74.175,22.675
  pour cut-out: 74.785,20.484 75.064,20.484 75.092,20.457 75.092,20.709 74.722,20.709
  pour cut-out: 73.759,17.91 74.038,17.91 74.475,17.473 74.475,18.135 73.696,18.135
  pour cut-out: 71.339,35.225 71.618,35.225 73.017,33.826 73.017,35.45 71.276,35.45
  pour cut-out: 67.921,35.836 68.2,35.836 68.501,35.535 68.501,36.061 67.858,36.061
  pour cut-out: 63.5,41.599 63.779,41.599 63.806,41.572 63.806,41.824 63.437,41.824
  pour cut-out: 63.46,43.857 63.94,43.857 64.011,43.787 64.011,44.082 63.397,44.082
  pour cut-out: 67.072,42.201 67.351,42.201 67.422,42.131 67.422,42.426 67.01,42.426
  pour cut-out: 83.043,30.75 83.322,30.75 83.349,30.723 83.349,30.975 82.98,30.975
  pour cut-out: 79.778,9.925 79.807,9.954 80.1,9.954 80.1,10.071 79.954,9.925 79.778,9.925 79.778,10.132 79.767,10.143 79.785,10.161 80.181,10.161 80.181,9.963 80.19,9.954 80.037,9.954
  pour cut-out: 82.134,15.318 82.413,15.318 82.44,15.291 82.44,15.543 82.071,15.543
  pour cut-out: 81.425,17.273 81.486,17.334 81.873,17.334 81.873,17.568 81.882,17.577 81.756,17.703 81.315,17.703
  pour cut-out: 30.7,9.4 30.7,18.4 60.7,18.4 60.7,9.4
  pour cut-out: 108.35,7.275 108.35,12.825 113.75,12.825 113.75,7.275
Signal Layer 5:
  pour cut-out: 30.7,9.4 30.7,18.4 60.7,18.4 60.7,9.4
  pour cut-out: 108.35,7.275 108.35,12.825 113.75,12.825 113.75,7.275
Bottom Layer:
  pour cut-out: 68.826,46.526 68.885,46.467 69.669,46.467 69.714,46.422 69.624,46.332 69.624,46.08 69.198,46.08 68.878,46.4
  pour cut-out: 51.776,39.909 51.782,39.903 52.425,39.903 52.425,39.789 52.336,39.7 51.866,39.7 51.628,39.938
  pour cut-out: 49.117,39.877 49.138,39.898 50.068,39.898 50.068,39.779 50.039,39.75 49.911,39.877 49.117,39.877 49.117,39.836 49.201,39.752
  pour cut-out: 48.696,31.987 48.847,32.139 48.696,31.987 48.895,31.788 49.095,31.788 49.158,31.851
  pour cut-out: 51.53,28.768 51.53,27.82 51.432,27.722 51.155,27.999 50.715,27.999 50.715,28.701 50.783,28.768
  pour cut-out: 57.158,53.596 57.211,53.649 57.744,53.649 57.744,53.356 59.55,51.55 59.514,51.514 59.15,51.514 57.119,53.545
  pour cut-out: 108.347,7.275 108.353,12.825 113.747,12.825 113.747,7.275

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Top Overlay:
  lines w0.2: 87.2,56.025 88.65,56.025 ; 89.85,56.025 91.3,56.025
  text "5V" at 30.18,58.3 h1.2
  text "GND" at 32.385,58.3 h1.2
  text "D0" at 35.425,58.3 h1.2
  text "D1" at 37.965,58.3 h1.2
  text "D2" at 40.505,58.3 h1.2
  text "D3" at 43.045,58.3 h1.2
  text "D4" at 45.585,58.3 h1.2
  text "D5" at 48.125,58.3 h1.2
  text "D6" at 50.665,58.3 h1.2
  text "D7" at 53.205,58.3 h1.2
  text "D8" at 55.78,58.3 h1.2
  text "D13" at 57.985,58.3 h1.2
  text "D14" at 60.525,58.3 h1.2
  text "D15" at 63.065,58.3 h1.2
  text "GND" at 65.405,58.3 h1.2
  text "3V3" at 68.245,58.3 h1.2
  text "19" at 72.413,57.3 h1.5
  text "1" at 87.5,57.3 h1.5
  text "19" at 89.916,57.3 h1.5
  text "1" at 104.7,57.3 h1.5
  text "20" at 72.406,53.6 h1.5
  text "2" at 87.3,53.6 h1.5
  text "20" at 89.824,53.6 h1.5
  text "2" at 104.6,53.6 h1.5
  text "5V" at 30,51.6 h1.2
  text "GND" at 32.205,51.6 h1.2
  text "B9" at 35.425,51.6 h1.2
  text "B10" at 37.665,51.6 h1.2
  text "B11" at 40.205,51.6 h1.2
  text "NC" at 42.945,51.6 h1.2
  text "E8" at 45.585,51.6 h1.2
  text "E9" at 48.125,51.6 h1.2
  text "E10" at 50.465,51.6 h1.2
  text "E11" at 53.005,51.6 h1.2
  text "E12" at 55.48,51.6 h1.2
  text "E13" at 58.085,51.6 h1.2
  text "E14" at 60.625,51.6 h1.2
  text "E15" at 63.165,51.6 h1.2
  text "GND" at 65.405,51.6 h1.2
  text "3V3" at 68.245,51.6 h1.2
  text "SIMPLICITY" at 91.602,48.789 h1.6
  text "DEBUG" at 73.816,48.5 h1.6
  text "Light Sense" at 105,46.5 h2
  text "20" at 104.5,42.932 h1.5
  text "19" at 108.3,42.942 h1.5
  text "Leopard Gecko" at 75.1,41.9 h2.8
  text "RESET" at 96.237,32.13 h2
  text "EFM32LG990" at 80.811,22.653 h2
  text "2" at 104.5,16.4 h1.5
  text "1" at 108.3,16.4 h1.5
  text "LC Sense" at 106.146,13.329 h2
  text "LED1" at 65.252,12.172 h2
  text "LED0" at 70.05,12.172 h2
  text "BAT" at 15.7,9 h2
  text "USB" at 19.75,9 h2
  text "AEM" at 23.9,9 h2
  text "VMCU" at 28.785,7.5 h1.2
  text "GND" at 32.385,7.5 h1.2
  text "C0" at 35.45,7.5 h1.2
  text "C1" at 37.89,7.5 h1.2
  text "C2" at 40.43,7.5 h1.2
  text "C3" at 42.97,7.5 h1.2
  text "C4" at 45.51,7.5 h1.2
  text "C5" at 48.05,7.5 h1.2
  text "C6" at 50.59,7.5 h1.2
  text "C7" at 53.13,7.5 h1.2
  text "NC" at 55.57,7.5 h1.2
  text "F0" at 58.31,7.5 h1.2
  text "F1" at 60.85,7.5 h1.2
  text "F2" at 63.39,7.5 h1.2
  text "GND" at 65.405,7.5 h1.2
  text "3V3" at 68.245,7.5 h1.2
  text "BTN1" at 84.5,5 h2
  text "BTN0" at 96.5,5 h2
  text "VMCU" at 28.785,0.8 h1.2
  text "GND" at 32.385,0.8 h1.2
  text "A12" at 35.125,0.8 h1.2
  text "A13" at 37.665,0.8 h1.2
  text "A14" at 40.205,0.8 h1.2
  text "B15" at 43.045,0.8 h1.2
  text "E0" at 45.685,0.8 h1.2
  text "E1" at 48.225,0.8 h1.2
  text "E2" at 50.765,0.8 h1.2
  text "E3" at 53.205,0.8 h1.2
  text "NC" at 55.745,0.8 h1.2
  text "NC" at 58.285,0.8 h1.2
  text "F8" at 60.925,0.8 h1.2
  text "F9" at 63.465,0.8 h1.2
  text "GND" at 65.505,0.8 h1.2
  text "3V3" at 68.245,0.8 h1.2
Bottom Overlay:
  lines w0.152: 80.802,12.915 81.702,12.915 ; 80.802,20.943 81.702,20.943 ; 80.973,20.691 81.531,20.691 ; 81.009,12.636 81.567,12.636 ; 81.162,20.421 81.387,20.421 ; 81.171,12.348 81.396,12.348 ; 81.252,20.934 81.252,21.771 ; 81.27,12.942 81.27,13.779 ; 83.322,14.592 84.456,14.592 ; 83.322,22.592 84.456,22.592 ; 84.015,14.603 84.015,17.289 84.978,17.289 ; 84.033,22.591 84.033,19.872 84.996,19.872 ; 84.987,20.925 84.987,16.249 89.091,18.594 ; 85.005,20.925 89.097,18.587 ; 85.221,17.298 85.77,17.298 ; 85.23,19.881 85.779,19.881 ; 85.491,17.019 85.491,17.568 ; 87.219,22.592 89.719,22.592 ; 87.237,14.592 89.737,14.601 ; 89.088,18.592 91.338,18.592 ; 89.739,14.592 89.739,22.592 ; 102.099,20.399 106.9,20.399 ; 102.099,22.901 106.801,22.901 ; 102.099,25.401 106.9,25.401 ; 102.099,27.9 106.9,27.9 ; 102.099,30.399 106.9,30.399 ; 102.099,32.901 106.801,32.901 ; 102.099,35.401 106.9,35.401 ; 102.099,37.9 106.9,37.9 ; 102.099,40.399 106.9,40.399 ; 102.248,42.901 102.099,42.901 ; 103.451,22.901 106.9,22.901 ; 103.451,32.901 106.9,32.901 ; 104.5,17.9 104.5,42.901 ; 104.5,27.9 106.801,27.9 ; 102.099,42.901 106.9,42.901 106.9,17.9 102.099,17.9 102.099,42.901
  text "3V3" at 109.818,41.068 h1.7
  text "19" at 104.058,41.041 h1.7
  text "20" at 106.427,41.023 h1.7
  text "5V" at 110.925,38.845 h1.7
  text "18" at 106.443,38.557 h1.7
  text "17" at 104.103,38.538 h1.7
  text "I2C_SCL" at 101.484,36.077 h1.7
  text "15" at 104.094,36.073 h1.7
  text "16" at 106.506,36.064 h1.7
  text "I2C_SDA" at 113.382,36.059 h1.7
  text "13" at 104.031,33.607 h1.7
  text "14" at 106.47,33.561 h1.7
  text "UART_RX" at 114.183,33.422 h1.7
  text "12" at 106.443,30.987 h1.7
  text "11" at 104.103,30.969 h1.7
  text "UART_TX" at 113.949,30.92 h1.7
  text "10" at 106.47,28.585 h1.7
  text "SPI_CS" at 112.383,28.589 h1.7
  text "9" at 103.752,28.549 h1.7
  text "8" at 106.056,26.047 h1.7
  text "7" at 103.59,26.01 h1.7
  text "SPI_SCK" at 113.49,26.015 h1.7
  text "SPI_MISO" at 114.147,23.63 h1.7
  text "5" at 103.671,23.563 h1.7
  text "6" at 106.155,23.527 h1.7
  text "3" at 103.59,21.088 h1.7
  text "4" at 105.975,21.06 h1.7
  text "SPI_MOSI" at 114.138,20.975 h1.7
  text "2" at 106.022,18.675 h1.7
  text "1" at 103.527,18.63 h1.7
  text "VMCU" at 111.463,18.622 h1.7
  text "GND" at 101.646,18.559 h1.7
  text "BOARD INFO" at 19.8,15.7 h1.52
  text "BAT" at 7.4,4.1 h1.52
  text "GND" at 7.45,1.45 h1.52
  text "PCB2201B Rev A02" at 100.6,1.2 h1.52
Top Solder:
  lines w0.5: 0,1.2 ccw(c1.2,1.2) 1.2,0 113.8,0 ccw(c113.8,1.2) 115,1.2 115,58.8 ccw(c113.8,58.8) 113.8,60 1.2,60 ccw(c1.2,58.8) 0,58.8 0,1.2
Bottom Solder:
  lines w0.5: 0,1.2 ccw(c1.2,1.2) 1.2,0 113.8,0 ccw(c113.8,1.2) 115,1.2 115,58.8 ccw(c113.8,58.8) 113.8,60 1.2,60 ccw(c1.2,58.8) 0,58.8 0,1.2
BOARD OUTLINE:
  circle w0.1: c15.5,39 r1.5
  circle w0.1: c112,57 r1.5
  lines w0.1: 0,1.2 ccw(c1.2,1.2) 1.2,0 ; 0,1.2 ccw(c1.2,1.2) 1.2,0 ; 0,1.2 ccw(c1.2,1.2) 1.2,0 ; 0,1.2 ccw(c1.2,1.2) 1.2,0 ; 0,1.2 0,58.8 ; 0,1.2 0,58.8 ; 0,1.2 0,58.8 ; 0,1.2 0,58.8 ; 0,58.8 cw(c1.2,58.8) 1.2,60 ; 0,58.8 cw(c1.2,58.8) 1.2,60 ; 0,58.8 cw(c1.2,58.8) 1.2,60 ; 0,58.8 cw(c1.2,58.8) 1.2,60 ; 1.2,0 113.8,0 ; 1.2,0 113.8,0 ; 1.2,0 113.8,0 ; 1.2,0 113.8,0 ; 1.2,60 113.8,60 ; 1.2,60 113.8,60 ; 1.2,60 113.8,60 ; 1.2,60 113.8,60 ; 113.8,0 ccw(c113.8,1.2) 115,1.2 ; 113.8,0 ccw(c113.8,1.2) 115,1.2 ; 113.8,0 ccw(c113.8,1.2) 115,1.2 ; 113.8,0 ccw(c113.8,1.2) 115,1.2 ; 113.8,60 cw(c113.8,58.8) 115,58.8 ; 113.8,60 cw(c113.8,58.8) 115,58.8 ; 113.8,60 cw(c113.8,58.8) 115,58.8 ; 113.8,60 cw(c113.8,58.8) 115,58.8 ; 115,1.2 115,58.8 ; 115,1.2 115,58.8 ; 115,1.2 115,58.8 ; 115,1.2 115,58.8
Route Tool Path:
  lines w0.1: 1.2,-2.4 8.5,-2.4 ; 113.8,60 cw(c113.8,58.8) 115,58.8 ; 113.8,60 cw(c113.8,58.8) 115,58.8 ; 113.8,60 cw(c113.8,58.8) 115,58.8 ; 113.8,60 cw(c113.8,58.8) 115,58.8
  lines w2.4: 8.5,-1.2 1.2,-1.2 cw(c1.2,1.2) -1.2,1.2 -1.2,58.8 cw(c1.2,58.8) 1.2,61.2 8.5,61.2 ; 15.5,-1.2 56.5,-1.2 ; 15.5,61.2 56.5,61.209 ; 63.5,-1.2 94.5,-1.2 ; 63.5,61.2 94.5,61.2 ; 101.5,-1.2 113.8,-1.2 ccw(c113.8,1.2) 116.2,1.2 116.2,58.8 ccw(c113.8,58.8) 113.8,61.2 101.5,61.2
Top Component Outline:
  circle w0.102: c15.5,39 r1.5
  circle w0.102: c112,57 r1.5
  circle w0.102: c112,57 r2.5
  lines w0.1: 111.619,57 112.381,57 ; 112,56.619 112,57.381
Top Courtyard:
  circle w0.05: c15.5,39 r3
  circle w0.05: c112,57 r2.75
Top Component Center (Mech19):
  lines w0.05: 111.5,57 112.5,57 ; 112,56.5 112,57.5
Assembly Drawing Frame (Top):
  lines w0.2: -84.433,-36.263 -82.808,-36.263 ; -84.433,10.412 -82.808,10.412 ; -84.433,57.087 -82.808,57.087 ; -29.783,-84.513 -29.783,-82.913 ; -29.783,103.787 -29.783,105.387 ; 23.242,-84.513 23.242,-82.913 ; 23.242,103.787 23.242,105.387 ; 76.267,-84.513 76.267,-82.913 ; 76.267,103.787 76.267,105.387 ; 129.292,-84.513 129.292,-82.913 ; 129.292,103.787 129.292,105.387 ; 182.317,-36.238 183.942,-36.238 ; 182.317,10.437 183.942,10.437 ; 182.317,57.112 183.942,57.112 ; 183.942,-84.513 -84.433,-84.513 -84.433,105.387 183.942,105.387 183.942,-84.488 ; -82.808,-82.913 -82.808,103.787 182.317,103.787 182.317,-82.913 -82.808,-82.913
  text "5" at -56.458,104.312 h0.5
  text "4" at -3.433,104.287 h0.5
  text "3" at 49.592,104.287 h0.5
  text "2" at 102.617,104.287 h0.5
  text "1" at 155.742,104.287 h0.5
  text "D" at 182.992,80.187 h0.5
  text "D" at -83.758,80.162 h0.5
  text "C" at 182.992,33.487 h0.5
  text "C" at -83.758,33.462 h0.5
  text "B" at 182.992,-13.188 h0.5
  text "B" at -83.758,-13.213 h0.5
  text "A" at 182.992,-59.838 h0.5
  text "A" at -83.758,-59.863 h0.5
  text "5" at -56.458,-83.988 h0.5
  text "4" at -3.433,-84.013 h0.5
  text "3" at 49.592,-84.013 h0.5
  text "2" at 102.617,-84.013 h0.5
  text "1" at 155.742,-84.013 h0.5
Title Block (Top):
  drawing of 27 lines, arcs and shapes, not listed
  text "Board Title" at 112.717,-57.963 h2.5
  text "EFM32 Leopard Gecko Starter Kit" at 114.117,-63.513 h3.5
  text "Page Title" at 112.717,-67.688 h2.5
  text "Designed:" at 80.467,-71.438 h1.7
  text "Approved:" at 96.667,-71.438 h1.7
  text "Top Assembly" at 114.117,-71.588 h3.2
  text "SSK" at 81.992,-73.938 h2.2
  text "AKM" at 98.042,-73.938 h2.2
  text "Revision" at 170.617,-74.713 h1.7
  text "Document number" at 112.717,-74.988 h2.35
  text "Size" at 80.467,-76.188 h1.7
  text "Sheet Modified Date" at 85.392,-76.188 h1.7
  text "A02" at 170.892,-77.763 h2.7
  text "BRD2201B (PCB2201B Rev A02)" at 114.117,-77.863 h3.2
  text "A4" at 81.042,-78.038 h2
  text "'.Print_Date'" at 85.967,-78.038 h2
  text "Sheet" at 170.617,-80.388 h1.7
  text "COPYRIGHT SILICON LABORATORIES  INC. 2022" at 85.115,-81.396 h1.7
  text "CONFIDENTIAL -SUBJECT TO TERMS OF USE" at 125.097,-81.396 h1.7
  text "1" at 171.817,-82.338 h1.7
  text "of" at 174.942,-82.338 h1.7
  text "2" at 177.667,-82.338 h1.7
Assembly Drawing Frame (Bottom):
  lines w0.2: -84.433,-36.263 -82.808,-36.263 ; -84.433,10.412 -82.808,10.412 ; -84.433,57.087 -82.808,57.087 ; -29.783,-84.513 -29.783,-82.913 ; -29.783,103.787 -29.783,105.387 ; 23.242,-84.513 23.242,-82.913 ; 23.242,103.787 23.242,105.387 ; 76.267,-84.513 76.267,-82.913 ; 76.267,103.787 76.267,105.387 ; 129.292,-84.513 129.292,-82.913 ; 129.292,103.787 129.292,105.387 ; 182.317,-36.238 183.942,-36.238 ; 182.317,10.437 183.942,10.437 ; 182.317,57.112 183.942,57.112 ; 183.942,-84.513 -84.433,-84.513 -84.433,105.387 183.942,105.387 183.942,-84.488 ; -82.808,-82.913 -82.808,103.787 182.317,103.787 182.317,-82.913 -82.808,-82.913
  text "5" at -56.133,104.312 h0.5
  text "4" at -3.108,104.287 h0.5
  text "3" at 49.917,104.287 h0.5
  text "2" at 102.942,104.287 h0.5
  text "1" at 155.917,104.287 h0.5
  text "D" at 183.317,80.187 h0.5
  text "D" at -83.433,80.162 h0.5
  text "C" at 183.317,33.487 h0.5
  text "C" at -83.433,33.462 h0.5
  text "B" at 183.317,-13.188 h0.5
  text "B" at -83.433,-13.213 h0.5
  text "A" at 183.317,-59.838 h0.5
  text "A" at -83.433,-59.863 h0.5
  text "5" at -56.133,-83.988 h0.5
  text "4" at -3.108,-84.013 h0.5
  text "3" at 49.917,-84.013 h0.5
  text "2" at 102.942,-84.013 h0.5
  text "1" at 155.917,-84.013 h0.5
Title Block (Bottom):
  drawing of 27 lines, arcs and shapes, not listed
  text "Board Title" at -13.208,-57.963 h2.5
  text "EFM32 Leopard Gecko Starter Kit" at -14.608,-63.513 h3.5
  text "Page Title" at -13.208,-67.688 h2.5
  text "Approved:" at 2.842,-71.438 h1.7
  text "Designed:" at 19.042,-71.438 h1.7
  text "Bottom Assembly" at -14.608,-71.588 h3.2
  text "AKM" at 1.467,-73.938 h2.2
  text "SSK" at 17.517,-73.938 h2.2
  text "Revision" at -71.108,-74.713 h1.7
  text "Document number" at -13.208,-74.988 h2.35
  text "Sheet Modified Date" at 14.117,-76.188 h1.7
  text "Size" at 19.042,-76.188 h1.7
  text "A02" at -71.372,-77.763 h2.7
  text "BRD2201B (PCB2201B Rev A02)" at -14.608,-77.863 h3.2
  text "'.Print_Date'" at 13.542,-78.038 h2
  text "A4" at 18.467,-78.038 h2
  text "Sheet" at -71.108,-80.388 h1.7
  text "COPYRIGHT SILICON LABORATORIES  INC. 2022" at 14.281,-81.324 h1.7
  text "CONFIDENTIAL -SUBJECT TO TERMS OF USE" at -26.283,-81.412 h1.7
  text "2" at -78.158,-82.338 h1.7
  text "of" at -75.433,-82.338 h1.7
  text "2" at -72.308,-82.338 h1.7
Assembly Drawing Frame:
  lines w0.2: -91.424,-90.101 -91.424,110.374 192.076,110.374 192.076,-90.101 -91.424,-90.101
Mechanical 98:
  circle w0.013: c106.206,55.506 r1.25
  circle w0.013: c64.693,-0.477 r2
  circle w0.013: c35.293,-0.477 r2
  circle w0.013: c64.693,60.323 r2
  circle w0.013: c67.037,17.813 r1.25
  circle w0.013: c35.293,60.323 r2
  circle w0.013: c27.063,15.719 r1.25
  circle w0.013: c5.676,38.649 r1.25
  circle w0.013: c103.355,13.007 r1.25
  circle w0.013: c13.685,1.607 r1.25
  circle w0.013: c15.502,38.991 r1.55
  circle w0.013: c15.502,38.991 r1.55
  circle w0.013: c112.002,2.991 r1.55
  circle w0.013: c112.002,56.992 r1.55
  lines w0.013: 67.293,55.346 67.293,65.323 ; 30.293,-5.477 69.693,-5.477 69.693,4.523 30.293,4.523 30.293,-5.477 ; 30.293,55.323 69.693,55.323 69.693,65.323 30.293,65.323 30.293,55.323
  text "Pressure" at 47.486,59.887 h1.52
  text "Hole" at 111.367,56.712 h0.76
  text "Pressure / (NM)" at 105.398,54.934 h0.51
  text "Pressure" at 4.814,38.551 h0.51
  text "Guide / hole" at 14.72,38.424 h0.76
  text "Guide / hole" at 14.72,38.424 h0.76
  text "Pressure / (NM)" at 66.155,17.342 h0.51
  text "Pressure / (NM)" at 25.642,15.183 h0.51
  text "Pressure" at 102.477,12.77 h0.51
  text "Guide / hole" at 111.113,2.356 h0.76
  text "Pressure / (NM)" at 12.815,1.086 h0.51
  text "Pressure" at 47.486,-1.327 h1.52